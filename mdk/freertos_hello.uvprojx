# Keil uVision project freertos_hello.uvprojx, settings and files
target freertos_hello Debug (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MKL46Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.12.0
  cpu: CPUTYPE("Cortex-M0+")
  output: freertos_hello.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG, CPU_MKL46Z256VLL4, FSL_RTOS_FREE_RTOS, FRDM_KL46Z, FREEDOM
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../rtos/freertos_8.2.3/Source/portable/RVDS/ARM_CM0;../../../../../rtos/freertos_8.2.3/Source/include;../../../../../CMSIS/Include;../../../../../devices;../../../../../devices/MKL46Z4/drivers;..;../../../../../devices/MKL46Z4/utilities;../../../../../rtos/freertos_8.2.3/Source;../../..;../../../../../devices/MKL46Z4
  asm misc: --cpreproc_opts '-DDEBUG'
  asm include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MKL46Z256xxx4_flash.scf
  link misc: --remove
  group startup
    ../../../../../devices/MKL46Z4/arm/: startup_MKL46Z4.s
    ../../../../../devices/MKL46Z4/: system_MKL46Z4.c system_MKL46Z4.h
  group freertos:portable
    ../../../../../rtos/freertos_8.2.3/Source/portable/RVDS/ARM_CM0/: port.c portmacro.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKL46Z4/drivers/: fsl_lpsci.h fsl_lpsci.c fsl_uart.h fsl_uart.c fsl_port.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c fsl_i2c.c fsl_i2c.h
  group source
    ../: FreeRTOSConfig.h freertos_hello.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../devices/MKL46Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
  group freertos
    ../../../../../rtos/freertos_8.2.3/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../../../rtos/freertos_8.2.3/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
    ../../../../../rtos/freertos_8.2.3/Source/portable/MemMang/: heap_4.c
target freertos_hello Release (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  cpu: CPUTYPE("Cortex-M0+")
  output: freertos_hello.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG, CPU_MKL46Z256VLL4, FSL_RTOS_FREE_RTOS, FRDM_KL46Z, FREEDOM
  c misc: as above
  c include: as above
  asm include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MKL46Z256xxx4_flash.scf
  link misc: --remove
